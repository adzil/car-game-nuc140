# Keil uVision project car-game-nuc140.uvprojx, settings and files
target NU-LB-NUC140 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: car-game-nuc140
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Main
    ./: main.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Driver:CLK 3.00.002, Device:Startup 3.00.002
